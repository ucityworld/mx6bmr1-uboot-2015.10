## board/freescale/mx6bmr1/Kconfig
```kconfig
if TARGET_MX6BMR1

config SYS_BOARD
	default "mx6bmr1"

config SYS_VENDOR
	default "freescale"

config SYS_CONFIG_NAME
	default "mx6bmr1"

endif
```
